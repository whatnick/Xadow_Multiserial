# Repository whatnick/Xadow_Multiserial

## EAGLE design Xadow MultiSerial.brd

Parts:
5V: 1,6/0,8
C1: 15pF; C0603
C2: 22pF; C0603
C3, C4: 10uF; C0805K
D1, D3: RED; LED0603
D2, D4: GRN; LED0603
GND: 1,6/0,8
IC2: LP298XS; SOT23-5L
J1: MINI-USB-5P-3400020P1; MINI-B-SMD
J2, J3, J4: 12p 0.5mm bottom contact; 12P-0.5
R3, R4, R5, R6: 150; R0603
R7: 10K; 1206-8-3.3X2.4
RXB_5: 1,6/0,8
TXB_5: 1,6/0,8
U1: SC16IS752; TSSOP28
U2: BSS138PS; SOT65P210X110-6N
X1: CTS_32X25_SMD; CTS_32X25

Connections:
+3V3: C3.1, C4.1, D1.+, D2.+, D3.+, D4.+, IC2.5 (VOUT), J2.5, J2.8, J3.5, J3.8, J4.5, J4.8, R7.5 (2), R7.6 (2), U1.5 (/RESET), U1.8 (VDD), U2.2 (G1), U2.5 (G2)
+5V: 5V.1, IC2.1 (VIN), IC2.3 (EN), J1.1 (VCC), R7.1, R7.2 (1)
GND: C1.1, C2.1, C3.2, C4.2, GND.1, IC2.2 (GND), J1.5 (GND), J1.P$1 (GND), J1.P$2 (GND), J1.P$3 (GND), J1.P$4 (GND), J2.6, J2.7, J2.P1, J2.P2, J3.6, J3.7, J3.P1, J3.P2, J4.6, J4.7, J4.P1, J4.P2, U1.9 (I2C/SPI), U1.14 (SDA/VSS), U1.22 (VSS), X1.2 (GND), X1.4 (GND)
GPIO0: J1.2 (DM), U1.18 (GPIO0/DSRB)
GPIO1: J1.4 (ID), U1.19 (GPIO1/DTRB)
unnamed: C1.2, U1.6 (XTAL1), X1.1 (X1)
unnamed: C2.2, U1.7 (XTAL2), X1.3 (X2)
unnamed: D1.-, R3.2
unnamed: D2.-, R4.2
unnamed: D3.-, R5.2
unnamed: D4.-, R6.2
PB1/D15/SCK: J2.1, J3.12, U1.13 (SCL/SCLK)
PB2/D16/MOSI: J2.2, J3.11, U1.11 (A1/SI)
PB3/D14/MISO: J2.3, J3.10, U1.12 (NC/SO)
PD0/SCL/D3: J2.9, J3.4
PD1/SDA/D2: J2.10, J3.3
PD2/RXI/D0: J2.11, J3.2
PD3/TXO/D1: J2.12, J3.1
PF0/A5: J2.4, J3.9, U1.10 (A0/CS)
RXA: J4.11, R3.1, U1.4 (RXA)
RXB: R5.1, R7.3 (1), U1.24 (RXB), U2.1 (S1)
RXB_5: R7.8 (2), RXB_5.1, U2.6 (D1)
TXA: J4.12, R4.1, U1.3 (TXA)
TXB: R6.1, R7.4 (1), U1.23 (TXB), U2.4 (S2)
TXB_5: J1.3 (DP), R7.7 (2), TXB_5.1, U2.3 (D2)

Notes on the sheet:
Tisham Dhar
v0.1a

Board: 2 copper layers, 25.4 x 20.3 mm, 25 parts (2 on the bottom side), 25 nets.

## Commit log

2014-09-12 Add Xadow multiserial
2014-09-12 Move text
2014-09-14 Added level shifter MOSFETs
2014-09-15 Arranged level shifter mosfets
2014-09-15 Added through hole pads and adjusted labels
2014-09-16 Fixed errors and relayed out, last attempt with MOSFET level shifter, need to try TXS shifter
2014-09-17 Added TXS based level translation
2014-09-17 Changed author
2014-09-18 Changed to 5x3 crystal
2014-09-18 Changed caps to match crystal load
2015-02-25 Added mini usb and mosfet based level shifter
2015-02-25 Silk screen cleanup
2015-02-26 Silkscreen fixes
2015-03-06 Converted board to SPI
2015-03-19 Added a 3V3 LDO to grab power
2015-06-16 Changed to Seeed DRU
